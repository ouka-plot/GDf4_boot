# Keil uVision project Boot.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: GD32F470_MD,__TARGET_FPU_VFP
  c include: ..\User;..\Driver\LIB\Include;..\Driver\CMSIS\Include;..\Driver\SYSTEM\Include;..\Driver;..\Driver\BSP\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: RTE_Components.h main.c
  group Drive/BSP
    ../Driver/BSP/Source/: fmc.c usart.c iic.c gd25q40e.c spi.c AT24c256.c boot.c
  group Drive/CMSIS
    ../Driver/CMSIS/Source/: startup_gd32f407_427.s system_gd32f4xx.c
  group Drive/LIB
    ../Driver/LIB/Source/: gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_pmu.c gd32f4xx_usart.c gd32f4xx_dma.c gd32f4xx_spi.c gd32f4xx_fmc.c
  group Drive/SYSTEM
    ../Driver/SYSTEM/Source/: gd32f4xx_it.c systick.c delay.c
